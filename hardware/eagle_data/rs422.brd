# Repository kaz19610303/SPRESENSE_RS422_485

File README.md:

Sonyのマイコンボード Spresense用のRS-422/485拡張ボードです。

RS-422/485通信はその長距離通信が可能な故に今でも工場とかでは幅広く使われています。  
RS-422、RS-485 共に***差動信号による伝送***で***10Mbps***のスピードで､最大***1.2km***までデータの伝送が可能です。  
RS-422とRS-485の違いは1ライン当たりのドライバ、レシーバーの数と全2重、Point to Pointと半2重、マルチドロップの違いです。  

RS-422/485に関する詳しい説明は省かせていただきますのでご自身で検索して下さい。  

このボードに使用しているRS-422/485のチップは***Analog Devices社のADM2582EBRWZ***です。  
このチップはロジック部分と通信部分がアイソレーションされていて、  
最高通信レート: 16 Mbps、1ラインに256ノードの接続可能となっています。  

詳しくは以下のデータシートをご覧下さい。  
[ADM2582EBRWZ データシート](https://www.mouser.jp/datasheet/2/609/adm2582e_2587e-1503113.pdf)  

ジャンパー設定  
SJ1　受信イネーブル制御ピン選択　1: EMMC_DATA3　3:I2S_DIN  
SJ2　送信イネーブル制御ピン選択　1: EMMC_DATA2　3:I2S_DOUT  
SJ3　ショートでRXラインの終端抵抗有効  
SJ4　ショート:RS-485 オープン:RS-422  
SJ5　ショート:RS-485 オープン:RS-422  
(SJ4とSJ5は両方オープンまたは両方ショートに設定してください)  

CN3はアイソレーション電源出力です。  
1、2ピン 3.3v  
3、4ピン GND  

[この基板の販売ページ](https://nextstep.official.ec/items/38434310)

## EAGLE design hardware/eagle_data/rs422.brd

Parts:
C1, C2: 1uF; C0603K
C3, C7, C9, C11: 100nF; C0603K
C4, C10: 10uF; C0603K
C5: 0.1uF; C0603K
C6, C12: 10nF; C0603K
C8, C13: 4.7uf; C0603K
CN1: 1X4
FL1, FL2: BLM21PG121SN1D; BEADC2012X105N
IC1: MCP1700T-3302E_TT; SOT95P237X112-3N
IC2: ADM2582EBRWZ; SOIC127P1032X265-20N
IC3: TXB0106PWR; SOP65P640X120-16N
J1: 1776112-4; TE_1776112-4
R1, R2: 10k; R0603
R3, R4, R5, R6, R8, R9, R10, R11: 10; R0603
R7: 100; R0603
SJ1, SJ2: SJ2W; SJ_2
SJ3, SJ4, SJ5: SJ
SV1, SV2: FE13-1; FE13

Connections:
1V8: C8.2, IC3.2 (VCCA), IC3.8 (OE), SV2.2
1V8*: SV1.11
+3V3: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C13.1, IC1.2 (VOUT), IC2.2 (VCC), IC2.8 (VCC_1), IC3.15 (VCCB), R1.2
+3V3*: SV1.10
CTS: SV1.5
DE: IC2.6 (DE), IC3.13 (B3), R2.2
EMMC_DATA2: SJ2.1, SV2.5
EMMC_DATA3: SJ1.1, SV2.4
EXT_VDD: C1.1, IC1.3 (VIN), SV2.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C13.2, IC1.1 (GND), IC2.1 (GND1), IC2.3 (GND1_1), IC2.9 (GND1_2), IC2.10 (GND1_3), IC3.9 (GND), R2.1, SV1.1
GND2: C11.2, C12.2, CN1.3, CN1.4, FL2.2, IC2.16 (GND2_2), IC2.20 (GND2_3)
GND*: SV2.10
I2C_SCL: SV2.11
I2C_SDA: SV2.12
I2S_BCK: SV1.6
I2S_DIN: SJ1.3, SV2.6
I2S_DOUT: SJ2.3, SV2.7
I2S_LRCK: SV1.7
unnamed: IC2.13 (Y), R8.1, SJ4.1
unnamed: IC2.15 (Z), R9.1, SJ5.1
unnamed: IC2.18 (A), R7.1, R10.1, SJ4.2
unnamed: IC2.17 (B), R11.1, SJ3.2, SJ5.2
unnamed: C9.1, C10.1, FL1.1, IC2.12 (VISOOUT)
unnamed: R3.1, SJ1.2
unnamed: R7.2, SJ3.1
unnamed: IC3.3 (A2), R3.2
unnamed: IC3.4 (A3), R4.2
unnamed: IC3.5 (A4), R5.2
unnamed: C9.2, C10.2, FL2.1, IC2.11 (GND2), IC2.14 (GND2_1)
unnamed: IC3.6 (A5), R6.2
unnamed: R4.1, SJ2.2
unnamed: J1.1, R8.2
unnamed: J1.2, R9.2
unnamed: J1.3, R10.2
unnamed: J1.4, R11.2
REN: IC2.5 (!RE), IC3.14 (B2), R1.1
RTS: SV1.4
RX: R5.1, SV1.3
RXD: IC2.4 (RXD), IC3.12 (B4)
SEN_AIN4: SV1.13
SEN_AIN5: SV2.13
SEN_IRQ_IN: SV1.12
SPI_CS: SV1.8
SPI_MISO: SV2.8
SPI_MOSI: SV2.9
SPI_SCK: SV1.9
TX: R6.1, SV1.2
TXD: IC2.7 (TXD), IC3.11 (B5)
VCCIO: C11.1, C12.1, CN1.1, CN1.2, FL1.2, IC2.19 (VISOIN)
XRST_PIN_1.8V: SV2.1

Notes on the sheet:
TX+
TX-
RX+
RX-
Spresense コネクター
スタッカブル用
RS-422/485 for SONY Spresense NS-SPR-0301
+3.3V
GND
アイソレーション電源出力
終端抵抗
2020/06/20
Next Step LLC

Board: 2 copper layers, 21.6 x 50.0 mm, 38 parts (16 on the bottom side), 33 nets.

File hardware/bom/bom.xlsx:

Parts | Qty | Value | Device | Description | MANUFACTURER_NAME | MANUFACTURER_PART_NUMBER
C1, C2 | 2 | 1uF 6.3V 10 % | C-EUC0603K | CAPACITOR, European symbol | KEMET | C0603C105K8RAC
C3, C5, C7, C9, C11 | 5 | 100nF 6.3V 10 % | C-EUC0603K | CAPACITOR, European symbol | KEMET | C0603C104K8RACTM
C4, C10 | 2 | 10uF 6.3V 10% | C-EUC0603K | CAPACITOR, European symbol | Taiyo Yuden | JMK107ABJ106KA-T
C6, C12 | 2 | 10nF 6.3V 10 % | C-EUC0603K | CAPACITOR, European symbol | Wurth Elektronik | 885012206014
C8, C13 | 2 | 4.7uf 6.3V 10% | C-EUC0603K | CAPACITOR, European symbol | Samsung Electro-Mechanics | CL10A475KQ8NNNC
FL1, FL2 | 2 | BLM21PG121SN1D | BLM21PG121SN1D | BLM21_N1D Series EMI Suppression Filter 120+/-25% at 100MHz 3A @85 | Murata Electronics | BLM21PG121SN1D
IC1 | 1 | MCP1700T-3302E_TT | MCP1700T-3302E_TT | LDO voltage regulator 250mA Isupply 1uA | Microchip | MCP1700T-3302E/TT
IC2 | 1 | ADM2582EBRWZ | ADM2582EBRWZ | ADM2582EBRWZ, Line Transceiver 16Mbit/s Differential, 3.3 V, 5 V, 20-Pin SOIC W | Analog Devices | ADM2582EBRWZ
IC3 | 1 | TXB0106PWR | TXB0106PWR | 6-Bit Bidirectional Voltage-Level Translator with Auto Direction Sensing and +/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 | Texas Instruments | TXB0106PWR
R1, R2 | 2 | 10k 1/10W 10% | R-US_R0603 | RESISTOR, American symbol | Vishay / Dale | CRCW060310K0JNEBC
R3, R4, R5, R6, R8, R9, R10, R11 | 8 | 10 1/10W 10% | R-US_R0603 | RESISTOR, American symbol | Vishay / Dale | CRCW060310R0FKEAC
R7 | 1 | 100 1/10W 10% | R-US_R0603 | RESISTOR, American symbol | Yageo | RC0603JR-07100RL
J1 | 1 | 1776112-4 | 1776112-4 |  | TE Connectivity | 1776112-4
SV1, SV2 | 2 |  | FE13-1 | FEMALE HEADER | 日本コネクト工業ニホンコウギョウ | HSCSW-S13G-H3.5-L5.6
SJ1, SJ2 | 2 |  | SJ2W | SMD solder JUMPER
SJ3, SJ4, SJ5 | 3 |  | SJ | SMD solder JUMPER
CN1 | 1 | 1X4 | 1X4

## Commit log

2022-01-18 Spresens_rs485_test01 upload
2022-02-06 Spresense IDE Sample program (rs422)
